# Keil uVision project TX.uvproj, settings and files
target TX (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TX +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c SPI.c USART.c DW1000.c delay.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c MPU6050.c utils.c solve.c solve.h
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c misc.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_tim.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c stm32f10x_pwr.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Readme
    ../: readme.txt README.md
